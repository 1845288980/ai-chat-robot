#include "iic.h"

#include <string.h>

#include "driver/i2c_master.h"
#include "esp_log.h"
#include "freertos/FreeRTOS.h"
#include "freertos/semphr.h"

#define IIC_OLED_I2C_PORT       I2C_NUM_0
#define IIC_OLED_I2C_SPEED_HZ   400000
#define IIC_OLED_TIMEOUT_MS     1000
#define IIC_OLED_PAGE_COUNT     (IIC_OLED_HEIGHT / 8)
#define IIC_OLED_FONT_WIDTH     5
#define IIC_OLED_CHAR_WIDTH     6
#define IIC_OLED_CHAR_HEIGHT    8

static const char *TAG = "ssd1306";
static i2c_master_bus_handle_t s_i2c_bus;
static i2c_master_dev_handle_t s_oled_device;
static uint8_t s_frame_buffer[IIC_OLED_WIDTH * IIC_OLED_PAGE_COUNT];
static SemaphoreHandle_t s_framebuffer_mutex;

/* 5x7 font, ASCII 0x20 (space) through 0x7F. Each byte is one vertical column. */
static const uint8_t s_font_5x7[][IIC_OLED_FONT_WIDTH] = {
    {0x00,0x00,0x00,0x00,0x00},{0x00,0x00,0x5F,0x00,0x00},{0x00,0x07,0x00,0x07,0x00},{0x14,0x7F,0x14,0x7F,0x14},
    {0x24,0x2A,0x7F,0x2A,0x12},{0x23,0x13,0x08,0x64,0x62},{0x36,0x49,0x55,0x22,0x50},{0x00,0x05,0x03,0x00,0x00},
    {0x00,0x1C,0x22,0x41,0x00},{0x00,0x41,0x22,0x1C,0x00},{0x14,0x08,0x3E,0x08,0x14},{0x08,0x08,0x3E,0x08,0x08},
    {0x00,0x50,0x30,0x00,0x00},{0x08,0x08,0x08,0x08,0x08},{0x00,0x60,0x60,0x00,0x00},{0x20,0x10,0x08,0x04,0x02},
    {0x3E,0x51,0x49,0x45,0x3E},{0x00,0x42,0x7F,0x40,0x00},{0x42,0x61,0x51,0x49,0x46},{0x21,0x41,0x45,0x4B,0x31},
    {0x18,0x14,0x12,0x7F,0x10},{0x27,0x45,0x45,0x45,0x39},{0x3C,0x4A,0x49,0x49,0x30},{0x01,0x71,0x09,0x05,0x03},
    {0x36,0x49,0x49,0x49,0x36},{0x06,0x49,0x49,0x29,0x1E},{0x00,0x36,0x36,0x00,0x00},{0x00,0x56,0x36,0x00,0x00},
    {0x08,0x14,0x22,0x41,0x00},{0x14,0x14,0x14,0x14,0x14},{0x00,0x41,0x22,0x14,0x08},{0x02,0x01,0x51,0x09,0x06},
    {0x32,0x49,0x79,0x41,0x3E},{0x7E,0x11,0x11,0x11,0x7E},{0x7F,0x49,0x49,0x49,0x36},{0x3E,0x41,0x41,0x41,0x22},
    {0x7F,0x41,0x41,0x22,0x1C},{0x7F,0x49,0x49,0x49,0x41},{0x7F,0x09,0x09,0x09,0x01},{0x3E,0x41,0x49,0x49,0x7A},
    {0x7F,0x08,0x08,0x08,0x7F},{0x00,0x41,0x7F,0x41,0x00},{0x20,0x40,0x41,0x3F,0x01},{0x7F,0x08,0x14,0x22,0x41},
    {0x7F,0x40,0x40,0x40,0x40},{0x7F,0x02,0x0C,0x02,0x7F},{0x7F,0x04,0x08,0x10,0x7F},{0x3E,0x41,0x41,0x41,0x3E},
    {0x7F,0x09,0x09,0x09,0x06},{0x3E,0x41,0x51,0x21,0x5E},{0x7F,0x09,0x19,0x29,0x46},{0x46,0x49,0x49,0x49,0x31},
    {0x01,0x01,0x7F,0x01,0x01},{0x3F,0x40,0x40,0x40,0x3F},{0x1F,0x20,0x40,0x20,0x1F},{0x3F,0x40,0x38,0x40,0x3F},
    {0x63,0x14,0x08,0x14,0x63},{0x07,0x08,0x70,0x08,0x07},{0x61,0x51,0x49,0x45,0x43},{0x00,0x7F,0x41,0x41,0x00},
    {0x02,0x04,0x08,0x10,0x20},{0x00,0x41,0x41,0x7F,0x00},{0x04,0x02,0x01,0x02,0x04},{0x40,0x40,0x40,0x40,0x40},
    {0x00,0x01,0x02,0x04,0x00},{0x20,0x54,0x54,0x54,0x78},{0x7F,0x48,0x44,0x44,0x38},{0x38,0x44,0x44,0x44,0x20},
    {0x38,0x44,0x44,0x48,0x7F},{0x38,0x54,0x54,0x54,0x18},{0x08,0x7E,0x09,0x01,0x02},{0x0C,0x52,0x52,0x52,0x3E},
    {0x7F,0x08,0x04,0x04,0x78},{0x00,0x44,0x7D,0x40,0x00},{0x20,0x40,0x44,0x3D,0x00},{0x7F,0x10,0x28,0x44,0x00},
    {0x00,0x41,0x7F,0x40,0x00},{0x7C,0x04,0x18,0x04,0x78},{0x7C,0x08,0x04,0x04,0x78},{0x38,0x44,0x44,0x44,0x38},
    {0x7C,0x14,0x14,0x14,0x08},{0x08,0x14,0x14,0x18,0x7C},{0x7C,0x08,0x04,0x04,0x08},{0x48,0x54,0x54,0x54,0x20},
    {0x04,0x3F,0x44,0x40,0x20},{0x3C,0x40,0x40,0x20,0x7C},{0x1C,0x20,0x40,0x20,0x1C},{0x3C,0x40,0x30,0x40,0x3C},
    {0x44,0x28,0x10,0x28,0x44},{0x0C,0x50,0x50,0x50,0x3C},{0x44,0x64,0x54,0x4C,0x44},{0x00,0x08,0x36,0x41,0x00},
    {0x00,0x00,0x7F,0x00,0x00},{0x00,0x41,0x36,0x08,0x00},{0x10,0x08,0x08,0x10,0x08},{0x00,0x00,0x00,0x00,0x00}
};

static esp_err_t oled_send_commands(const uint8_t *commands, size_t command_count)
{
    uint8_t transaction[32] = {0};
    if (command_count > sizeof(transaction) - 1 || s_oled_device == NULL) return ESP_ERR_INVALID_ARG;
    transaction[0] = 0x00;
    memcpy(&transaction[1], commands, command_count);
    return i2c_master_transmit(s_oled_device, transaction, command_count + 1, IIC_OLED_TIMEOUT_MS);
}

esp_err_t iic_oled_init(gpio_num_t sda_gpio, gpio_num_t scl_gpio, uint8_t i2c_address)
{
    if (s_oled_device != NULL || s_i2c_bus != NULL) return ESP_ERR_INVALID_STATE;
    if (s_framebuffer_mutex == NULL) {
        s_framebuffer_mutex = xSemaphoreCreateMutex();
        if (s_framebuffer_mutex == NULL) return ESP_ERR_NO_MEM;
    }
    i2c_master_bus_config_t bus_config = {
        .i2c_port = IIC_OLED_I2C_PORT, .sda_io_num = sda_gpio, .scl_io_num = scl_gpio,
        .clk_source = I2C_CLK_SRC_DEFAULT, .glitch_ignore_cnt = 7, .flags.enable_internal_pullup = true,
    };
    esp_err_t ret = i2c_new_master_bus(&bus_config, &s_i2c_bus);
    if (ret != ESP_OK) return ret;
    i2c_device_config_t device_config = {
        .dev_addr_length = I2C_ADDR_BIT_LEN_7, .device_address = i2c_address, .scl_speed_hz = IIC_OLED_I2C_SPEED_HZ,
    };
    ret = i2c_master_bus_add_device(s_i2c_bus, &device_config, &s_oled_device);
    if (ret != ESP_OK) { i2c_del_master_bus(s_i2c_bus); s_i2c_bus = NULL; return ret; }
    const uint8_t init_commands[] = {
        0xAE, 0xD5,0x80, 0xA8,0x3F, 0xD3,0x00, 0x40, 0x8D,0x14, 0x20,0x00,
        0xA1, 0xC8, 0xDA,0x12, 0x81,0xCF, 0xD9,0xF1, 0xDB,0x40, 0xA4, 0xA6, 0xAF,
    };
    ret = oled_send_commands(init_commands, sizeof(init_commands));
    if (ret != ESP_OK) { ESP_LOGE(TAG, "SSD1306 at 0x%02X did not acknowledge: %s", i2c_address, esp_err_to_name(ret)); return ret; }
    iic_oled_clear();
    return iic_oled_update();
}

esp_err_t iic_oled_deinit(void)
{
    if (s_oled_device == NULL || s_i2c_bus == NULL) return ESP_ERR_INVALID_STATE;
    esp_err_t ret = i2c_master_bus_rm_device(s_oled_device);
    if (ret == ESP_OK) { s_oled_device = NULL; ret = i2c_del_master_bus(s_i2c_bus); s_i2c_bus = NULL; }
    return ret;
}

void iic_oled_clear(void) { memset(s_frame_buffer, 0, sizeof(s_frame_buffer)); }

esp_err_t iic_oled_update(void)
{
    if (s_oled_device == NULL) return ESP_ERR_INVALID_STATE;
    xSemaphoreTake(s_framebuffer_mutex, portMAX_DELAY);
    uint8_t page_data[IIC_OLED_WIDTH + 1];
    page_data[0] = 0x40;
    for (uint8_t page = 0; page < IIC_OLED_PAGE_COUNT; ++page) {
        const uint8_t page_command[] = { (uint8_t)(0xB0 + page), 0x00, 0x10 };
        esp_err_t ret = oled_send_commands(page_command, sizeof(page_command));
        if (ret != ESP_OK) { xSemaphoreGive(s_framebuffer_mutex); return ret; }
        memcpy(&page_data[1], &s_frame_buffer[page * IIC_OLED_WIDTH], IIC_OLED_WIDTH);
        ret = i2c_master_transmit(s_oled_device, page_data, sizeof(page_data), IIC_OLED_TIMEOUT_MS);
        if (ret != ESP_OK) { xSemaphoreGive(s_framebuffer_mutex); return ret; }
    }
    xSemaphoreGive(s_framebuffer_mutex);
    return ESP_OK;
}

esp_err_t iic_oled_set_text_row(uint8_t row, const char *text)
{
    if (s_oled_device == NULL || row >= IIC_OLED_PAGE_COUNT || text == NULL) {
        return ESP_ERR_INVALID_ARG;
    }
    xSemaphoreTake(s_framebuffer_mutex, portMAX_DELAY);
    memset(&s_frame_buffer[row * IIC_OLED_WIDTH], 0, IIC_OLED_WIDTH);
    iic_oled_write_string(0, row, text, true);
    xSemaphoreGive(s_framebuffer_mutex);
    return iic_oled_update();
}

void iic_oled_draw_pixel(uint8_t x, uint8_t y, bool on)
{
    if (x >= IIC_OLED_WIDTH || y >= IIC_OLED_HEIGHT) return;
    uint8_t *pixel_byte = &s_frame_buffer[(y / 8) * IIC_OLED_WIDTH + x];
    uint8_t pixel_mask = (uint8_t)(1U << (y & 0x07));
    if (on) *pixel_byte |= pixel_mask; else *pixel_byte &= (uint8_t)~pixel_mask;
}

void iic_oled_draw_char(uint8_t x, uint8_t y, char character, bool on)
{
    uint8_t glyph_index = ((unsigned char)character >= 0x20 && (unsigned char)character <= 0x7F) ?
        (uint8_t)((unsigned char)character - 0x20) : (uint8_t)('?' - 0x20);
    for (uint8_t column = 0; column < IIC_OLED_FONT_WIDTH; ++column) {
        uint8_t glyph_column = s_font_5x7[glyph_index][column];
        for (uint8_t row = 0; row < 7; ++row) {
            if ((glyph_column & (1U << row)) != 0U) iic_oled_draw_pixel(x + column, y + row, on);
        }
    }
}

void iic_oled_draw_string(uint8_t x, uint8_t y, const char *text, bool on)
{
    if (text == NULL) return;
    while (*text != '\0' && y + IIC_OLED_CHAR_HEIGHT <= IIC_OLED_HEIGHT) {
        if (*text == '\n') { x = 0; y += IIC_OLED_CHAR_HEIGHT; }
        else {
            if (x + IIC_OLED_CHAR_WIDTH > IIC_OLED_WIDTH) { x = 0; y += IIC_OLED_CHAR_HEIGHT; }
            if (y + IIC_OLED_CHAR_HEIGHT > IIC_OLED_HEIGHT) break;
            iic_oled_draw_char(x, y, *text, on); x += IIC_OLED_CHAR_WIDTH;
        }
        ++text;
    }
}

void iic_oled_write_string(uint8_t column, uint8_t row, const char *text, bool on)
{
    iic_oled_draw_string(column * IIC_OLED_CHAR_WIDTH, row * IIC_OLED_CHAR_HEIGHT, text, on);
}

esp_err_t iic_oled_set_invert(bool invert) { const uint8_t command = invert ? 0xA7 : 0xA6; return oled_send_commands(&command, 1); }
esp_err_t iic_oled_set_display_on(bool on) { const uint8_t command = on ? 0xAF : 0xAE; return oled_send_commands(&command, 1); }
